# Autodesk Inventor assembly: 21.1101 T-SLOT BAR 180
## iProperties
Created: 2006-12
Part Number: 21.1101 T-SLOT BAR 180
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
